# Enable SPI
ENABLE_SPI_BUS = "1"

# Enable UART
ENABLE_UART = "1"

# Enable MCP2515 CAN
ENABLE_CAN = "1"
CAN_OSCILLATOR = "8000000"
CAN0_INTERRUPT_PIN = "25"