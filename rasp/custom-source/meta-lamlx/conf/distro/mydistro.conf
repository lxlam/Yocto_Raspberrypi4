## rasp/custom-source/meta-ojt/conf/distro/mydistro.conf
```bitbake
require conf/distro/poky.conf

INIT_MANAGER = "systemd"
EXTRA_IMAGE_FEATURES += " ssh-server-openssh"
```
